File: Block Diagram.kicad_sch (KiCad schematic)
At the start: 0 parts

Commit message: [Schematic][Modify] Block Diagram
Other:
- note added: "+12V"
- note added: "+3V3"
- note added: "+5V"
